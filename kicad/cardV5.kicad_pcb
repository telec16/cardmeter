# Repository telec16/cardmeter

File README.md:

# Cardmeter

The pleasure of having a multimeter in your pocket !

## KiCad design kicad/cardV5.kicad_pcb

Parts:
BT1: Battery_Cell; LiPO_150m
C00: 10u; CP_Elec_3x5.4
C01: 470n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C02: 22u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C03, C31: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C10, C11: C; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C12, C17, C18, C20, C30: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C13: 1u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C14, C15, C16: 2u2; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D30, D31, D32, D33: LED_ALT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Charge; PinSocket_1x01_P2.54mm_Vertical
J10: Res; PinSocket_1x02_P2.54mm_Vertical
J11, J14: V+; Probing_pad
J12, J15: A+; Probing_pad
J13, J16: COM; Probing_pad
J20: UPDI; PinSocket_1x03_P2.54mm_Horizontal
JP01: VDDA bridge; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
JP02: GNDA bridge; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
R10: 6k8; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R11, R14, R17, R18: 820k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R12, R15: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R13, R16: 1; R_1210_3225Metric_Pad1.42x2.65mm_HandSolder
R30, R31, R32, R33: 330; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW00: ON/OFF; PinHeader_1x03_P2.54mm_Vertical
SW1, SW2, SW3, SW4: SW_Push; SW_SPST_EVQQ2
SW30: Light; PinHeader_1x03_P2.54mm_Vertical
TP10: R; Probing_pad
TP11: OUTA; Probing_pad
TP12: OUTB; Probing_pad
TP13: REF; Probing_pad
TP20: CLK; Probing_pad
TP21: MISO; Probing_pad
TP22: MOSI; Probing_pad
TP23: ~SCR_CS; Probing_pad
TP24: ~SCR_RST; Probing_pad
TP25: D~C; Probing_pad
TP26: A2; Probing_pad
TP27: A1; Probing_pad
TP28: A0; Probing_pad
TP29: ~INA_CS; Probing_pad
TP30: Vcap; Probing_pad
TP210: ~ADA_CS; Probing_pad
TP211: ~INB_CS; Probing_pad
TP212: ~ADB_CS; Probing_pad
U01: TS2940-3.3; SOT-223-3_TabPin2
U10: LM334Z; TO-92_Inline_Wide
U11, U12: AD8231; LFCSP-16-1EP_4x4mm_P0.65mm_EP2.1x2.1mm
U13: LTC2402; MSOP-10_3x3mm_P0.5mm
U14: LTC2315; TSOT-23-8_HandSoldering
U20: ATtiny1616; SOIC-20W_7.5x12.8mm_P1.27mm
U30: Nokia_3310_LCD; NOKIA_3310_LCD

Connections:
+2V5: R17.2, TP13.1, U12.7 (-INB), U12.8 (OUTB), U13.2 (FS)
+3V3: C02.1, C13.2, C16.2, C20.1, C30.1, D30.2 (A), D31.2 (A), D32.2 (A), D33.2 (A), J20.3, U01.3 (VO), U13.1 (VCC), U13.10 (Fo), U14.5 (OVdd), U20.1 (VDD), U30.4 (OSC), U30.9 (VCC)
+BATT: C00.1, C01.1, JP01.1, SW00.3 (C), U01.1 (VI)
/A0: TP28.1, U11.14 (A0), U12.14 (A0), U20.2 (PA4)
/A1: TP27.1, U11.15 (A1), U12.15 (A1), U20.3 (PA5)
/A2: TP26.1, U11.16 (A2), U12.16 (A2), U20.4 (PA6)
/CLK: TP20.1, U13.9 (SCK), U14.7 (SCK), U20.19 (PA3), U30.8 (SCLK)
/D~C: TP25.1, U20.14 (PC2), U30.6 (D/~C)
/LIGHT: R30.1, R31.1, R32.1, R33.1, SW30.3 (C)
/MISO: TP21.1, U13.8 (SDO), U14.6 (SDO), U20.17 (PA1)
/MOSI: TP22.1, U20.18 (PA2), U30.7 (SDIN)
/OUTA: TP11.1, U11.10 (OUTA), U13.4 (CH0)
/OUTB: TP12.1, U12.10 (OUTA), U14.4 (Ain)
/R: J10.1, R10.2, TP10.1, U10.3, U13.3 (CH1)
/REF: C14.1, U12.6 (+INB), U14.2 (Ref)
/SW1: SW1.1, U20.11 (PB0)
/SW2: SW2.1, U20.10 (PB1)
/SW3: SW3.1, U20.9 (PB2/OSC2)
/SW4: SW4.1, U20.8 (PB3/OSC1)
/UPDI: J20.2, U20.16 (UPDI/PA0)
/~ADA_CS: TP210.1, U13.7 (~CS), U20.7 (PB4)
/~ADB_CS: TP212.1, U14.8 (~CS), U20.15 (PC3)
/~INA_CS: TP29.1, U11.13 (~CS), U20.5 (PA7)
/~INB_CS: TP211.1, U12.13 (~CS), U20.6 (PB5)
/~SCR_CS: TP23.1, U20.12 (PC0), U30.5 (~SCE)
/~SCR_RST: TP24.1, U20.13 (PC1), U30.1 (~RST)
GNDA: C03.2, C12.2, C14.2, C15.1, C17.2, C18.2, J10.2, JP02.1, R18.1, U11.11 (-Vs), U11.17 (EPAD), U12.11 (-Vs), U12.17 (EPAD), U13.5 (ZS)
GNDD: BT1.2 (-), C00.2, C01.2, C02.2, C13.1, C16.1, C20.2, C30.2, C31.2, J20.1, JP02.2, SW1.2, SW2.2, SW3.2, SW4.2, SW30.2 (B), U01.2 (GND), U13.6 (GND), U14.3 (GND), U20.20 (GND), U30.3 (GND)
GNDREF: C12.1, J13.1, J16.1, R13.2, R16.2, U11.7 (-INB), U11.8 (OUTB), U11.9 (Ref), U12.9 (Ref)
unnamed: BT1.1 (+), SW00.2 (B)
unnamed: C10.1, R11.1, R12.2, U11.3 (+INA)
unnamed: C10.2, J12.1, R12.1, R13.1, U11.2 (-INA)
unnamed: C11.1, R14.1, R15.2, U12.3 (+INA)
unnamed: C11.2, J15.1, R15.1, R16.1, U12.2 (-INA)
unnamed: C31.1, TP30.1, U30.2 (VOUT)
unnamed: D30.1 (K), R30.2
unnamed: D31.1 (K), R31.2
unnamed: D32.1 (K), R32.2
unnamed: D33.1 (K), R33.2
unnamed: J1.1, SW00.1 (A)
unnamed: J11.1, R11.2
unnamed: J14.1, R14.2
unnamed: R10.1, U10.2
unnamed: R17.1, R18.2, U11.6 (+INB)
VDDA: C03.1, C15.2, C17.1, C18.1, JP01.2, U10.1, U11.5 (~SDN), U11.12 (+Vs), U12.5 (~SDN), U12.12 (+Vs), U14.1 (Vdd)

Board: 2 copper layers, 77 parts (10 on the bottom side), 45 nets, no tracks yet.

## KiCad design kicad/cardV4.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_103_1x20mm
C00: 10u; CP_Elec_3x5.4
C01: 470n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C02: 22u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C03, C31: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C04, C10, C11, C12, C20, C30: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C13, C14: 33p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D30, D31, D32, D33: LED_ALT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Charge; PinSocket_1x01_P2.54mm_Vertical
J10: AOP; PinSocket_1x03_P1.27mm_Vertical
J11: Volt1; PinSocket_1x02_P2.54mm_Vertical
J12: Volt2; PinSocket_1x02_P2.54mm_Vertical
J13: Amp; PinSocket_1x02_P2.54mm_Vertical
J14: Res; PinSocket_1x02_P2.54mm_Vertical
J20: UPDI; PinSocket_1x03_P2.54mm_Horizontal
JP01: VDDA bridge; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
JP02: GNDA bridge; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
JP20, JP21, JP22: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
R10, R11: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R12, R14: 820k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R13, R15: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R16: 1; R_1210_3225Metric_Pad1.42x2.65mm_HandSolder
R17: 6k8; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R30, R31, R32, R33: 330; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW00, SW30: ON/OFF; PinHeader_1x03_P2.54mm_Vertical
SW1, SW2, SW3, SW4: SW_Push; SW_SPST_EVQQ2
TP10: Ref; Probing_pad
TP11: V1; Probing_pad
TP12: V2; Probing_pad
TP14: R; Probing_pad
TP20: CLK; Probing_pad
TP21: MISO; Probing_pad
TP22: MOSI; Probing_pad
TP23: ~ADC_CS; Probing_pad
TP24: ~SCR_CS; Probing_pad
TP25: ~ADC_RST; Probing_pad
TP26: ~SCR_RST; Probing_pad
TP27: ~STANDBY; Probing_pad
TP28: ~RDY; Probing_pad
TP29: ~SYNC; Probing_pad
TP30: Vcap; Probing_pad
TP130: I+; Probing_pad
TP131: I-; Probing_pad
TP210: D~C; Probing_pad
U01: TS2940-3.3; SOT-223-3_TabPin2
U02: ADR291GT9Z; TO-92_Inline_Wide
U10: LT1178; SOIC-8_3.9x4.9mm_P1.27mm
U11: LM334Z; TO-92_Inline_Wide
U12: AD7731; SOIC-24W_7.5x15.4mm_P1.27mm
U20: ATtiny1616; SOIC-20W_7.5x12.8mm_P1.27mm
U30: Nokia_3310_LCD; NOKIA_3310_LCD
Y10: 4.9152MHz; Crystal_HC49-4H_Vertical

Connections:
+2V5: C04.1, U02.3, U12.14
+3V3: C02.1, C20.1, C30.1, D30.2 (A), D31.2 (A), D32.2 (A), D33.2 (A), J20.3, U01.3 (VO), U12.4, U12.23, U20.1 (VDD), U30.4 (OSC), U30.9 (VCC)
+BATT: C00.1, C01.1, JP01.1, SW00.3 (C), U01.1 (VI)
/CLK: TP20.1, U12.1, U20.19 (PA3), U30.8 (SCLK)
/D~C: TP210.1, U20.15 (PC3), U30.6 (D/~C)
/I+: J13.2, R16.1, TP130.1, U12.12
/I-: J13.1, R16.2, TP131.1, U12.13
/LIGHT: R30.1, R31.1, R32.1, R33.1, SW30.3 (C)
/MISO: TP21.1, U12.21, U20.17 (PA1)
/MOSI: TP22.1, U12.22, U20.18 (PA2), U30.7 (SDIN)
/R: J14.1, R17.2, TP14.1, U11.3, U12.16
/SW1: SW1.1, U20.11 (PB0)
/SW2: SW2.1, U20.10 (PB1)
/SW3: SW3.1, U20.9 (PB2/OSC2)
/SW4: SW4.1, U20.8 (PB3/OSC1)
/UPDI: J20.2, U20.16 (UPDI/PA0)
/V1: R12.2, R13.2, TP11.1, U12.10
/V2: R14.2, R15.2, TP12.1, U12.11
/~ADC_CS: TP23.1, U12.19, U20.3 (PA5)
/~ADC_RST: TP25.1, U12.6, U20.5 (PA7)
/~RDY: JP21.1 (A), TP28.1, U12.20
/~SCR_CS: TP24.1, U20.13 (PC1), U30.5 (~SCE)
/~SCR_RST: TP26.1, U20.14 (PC2), U30.1 (~RST)
/~STANDBY: JP22.1 (A), TP27.1, U12.18
/~SYNC: JP20.1 (A), TP29.1, U12.5
GNDA: C03.2, C04.2, C10.2, C11.2, C12.2, J14.2, JP02.1, R11.2, U02.2, U10.2, U12.8, U12.15, U12.17
GNDD: BT1.2 (-), C00.2, C01.2, C02.2, C13.1, C14.2, C20.2, C30.2, C31.2, J20.1, JP02.2, SW1.2, SW2.2, SW3.2, SW4.2, SW30.2 (B), U01.2 (GND), U12.24, U20.20 (GND), U30.3 (GND)
GNDREF: C11.1, J11.1, J12.2, R13.1, R15.1, TP10.1, U10.7, U10.8
unnamed: BT1.1 (+), SW00.2 (B)
unnamed: C13.2, U12.3, Y10.2
unnamed: C14.1, U12.2, Y10.1
unnamed: C31.1, TP30.1, U30.2 (VOUT)
unnamed: D30.1 (K), R30.2
unnamed: D31.1 (K), R31.2
unnamed: D32.1 (K), R32.2
unnamed: D33.1 (K), R33.2
unnamed: J1.1, SW00.1 (A)
unnamed: J10.1, U10.3
unnamed: J10.2, U10.4
unnamed: J10.3, U10.5
unnamed: J11.2, R12.1
unnamed: J12.1, R14.1
unnamed: JP20.2 (B), U20.6 (PB5)
unnamed: JP21.2 (B), U20.4 (PA6)
unnamed: JP22.2 (B), U20.2 (PA4)
unnamed: R10.2, R11.1, U10.1
unnamed: R17.1, U11.2
VDDA: C03.1, C10.1, C12.1, JP01.2, R10.1, U02.1, U10.6, U11.1, U12.9

Notes on the sheet:
Low-to-High Write Clock idle High
5pF
13pF

Board: 2 copper layers, 79.9 x 68.7 mm, 74 parts (21 on the bottom side), 48 nets.

## KiCad design kicad/CardMeterFrontEnd.kicad_pcb

Parts:
C1: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C3, C4: 2u2; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: V+; Probing_pad
J2: R-; Probing_pad
J3: A+; Probing_pad
J4: COM; Probing_pad
J5: Analog; PinHeader_1x03_P1.27mm_Vertical
J6: Gain; PinHeader_1x04_P1.27mm_Vertical
J7: ADC; PinHeader_1x05_P1.27mm_Vertical
JP1: ADC link; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP2: GND link; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
NT1: Net-Tie_2; NetTie-2_SMD_Pad0.5mm
R2: 470k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4: 1; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R5, R6, R7, R8: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: LTC1992; MSOP-8_3x3mm_P0.65mm
U2: AD8231; LFCSP-16-1EP_4x4mm_P0.65mm_EP2.1x2.1mm
U3: LTC2315; TSOT-23-8_HandSoldering

Connections:
/A0: J6.3, U2.14 (A0)
/A1: J6.2, U2.15 (A1)
/A2: J6.1, U2.16 (A2)
/SCK: J7.3, U3.7 (SCK)
/SDO: J7.4, U3.6 (SDO)
/~CS: J6.4, U2.13 (~CS)
/~CS_adc: J7.2, U3.8 (~CS)
GNDA: C1.2, C2.2, C3.1, J5.2, JP2.2 (B), NT1.1, U2.6 (+INB), U2.9 (Ref)
GNDD: C4.1, J7.5, NT1.2, U3.3 (GND)
unnamed: C1.1, U1.2 (VOCM), U1.7 (VMID)
unnamed: C2.1, U3.2 (Ref)
unnamed: J1.1, R2.2
unnamed: J2.1, R2.1, R3.2, R6.2
unnamed: J3.1, R3.1, R4.2, R5.2
unnamed: J4.1, JP2.1 (A), R4.1
unnamed: JP1.1 (A), U2.10 (OUTA)
unnamed: JP1.2 (B), U3.4 (Ain)
unnamed: R5.1, R7.2, U1.1 (-)
unnamed: R6.1, R8.1, U1.8 (+)
unnamed: R7.1, U1.4 (+), U2.3 (+INA)
unnamed: R8.2, U1.5 (-), U2.2 (-INA)
unnamed: U2.7 (-INB), U2.8 (OUTB)
VCC: C4.2, J7.1, U3.5 (OVdd)
VDDA: C3.2, J5.1, U1.3 (V+), U2.5 (~SDN), U2.12 (+Vs), U3.1 (Vdd)
VSSA: J5.3, U1.6 (V-), U2.11 (-Vs), U2.17 (EPAD)

Board: 2 copper layers, 26.7 x 13.0 mm, 24 parts (6 on the bottom side), 25 nets.

## Code that names these connections

File firmware/CardMeter/setup.h:

#ifndef SETUP_H_
#define SETUP_H_

#define F_CPU 20000000LL
#include <avr/io.h>
#include <util/delay.h>

typedef struct {
	uint8_t pin;
	VPORT_t * port;
} pin_t;

#define V5_F

/* V1
 * PA7 -> x
 * PA4/5/6 -> G0/1/2
 * PA3 -> CLK
 * PA2 <- MISO
 * PA1 -> MOSI
 * PA0 <- Prog
 *
 * PB5 -> x
 * PB4 -> x
 * PB0/1/2/3 <- SW1/2/3/4
 *
 * PC3 -> D/C
 * PC2 -> RST
 * PC1 -> _CS_SCR
 * PC0 -> _CS_ADC
 */ 

/* V2
 * PA7 -> x
 * PA4/5/6 -> G0/1/2
 * PA3 -> CLK
 * PA2 <- MISO
 * PA1 -> MOSI
 * PA0 <- Prog
 *
 * PB5 -> _CS_GAIN_A
 * PB4 -> _CS_GAIN_B
 * PB0/1/2/3 <- SW1/2/3/4
 *
 * PC3 -> D/C
 * PC2 -> RST
 * PC1 -> _CS_SCR
 * PC0 -> _CS_ADC
 */ 
 
 /* V4
  * PA7 -> _ADC_RST
  * PA6 <- _RDY
  * PA5 -> _ADC_CS
  * PA4 -> _STANDBY
  * PA3 -> CLK
  * PA2 -> MOSI
  * PA1 <- MISO
  * PA0 <- Prog
  *
  * PB5 -> _SYNC
  * PB4 -> x
  * PB0/1/2/3 <- SW1/2/3/4
  *
  * PC3 -> D/C
  * PC2 -> _SCR_RST
  * PC1 -> _SCR_CS
  * PC0 -> x					
  */ 
 
/* V5 (new frontend on V2 board)
 * PA7 -> x
 * PA4/5/6 -> G0/1/2
 * PA3 -> CLK
 * PA2 <- MISO
 * PA1 -> MOSI
 * PA0 <- Prog
 *
 * PB5 -> x
 * PB4 -> _CS_GAIN
 * PB0/1/2/3 <- SW1/2/3/4
 *
 * PC3 -> D/C
 * PC2 -> RST
 * PC1 -> _CS_SCR
 * PC0 -> _CS_ADC
 */ 

// Buttons
#define SW1 0
#define SW2 1
#define SW3 2
#define SW4 3

// Serial
extern const pin_t SCK; //PA3
extern const pin_t SDI; //PA2
extern const pin_t SDO; //PA1
extern const pin_t CS_SCR; //PC1
extern const pin_t CS_ADC; //PC0

// Gain
extern const pin_t CS_GAIN; //PB4

// Screen
extern const pin_t DC; //PC3
extern const pin_t RST; //PC2

void pinSetup();
void clockSetup();

#endif /* SETUP_H_ */

File firmware/CardMeter/setup.c:

/*		____u___
 * VDD-|	A	|-GND
 * PA4-|	T	|-PA3
 * PA5-|	t	|-PA2
 * PA6-|	i	|-PA1
 * PA7-|	n	|-PA0
 * PB5-|	y	|-PC3
 * PB4-|	1	|-PC2
 * PB3-|	6	|-PC1
 * PB2-|	1	|-PC0
 * PB1-|____6___|-PB0
 */

#include "setup.h"

#define PULLUPEN (1<<3)
#define INVEN (1<<7)

#define OSC20M (0b00<<0)
#define PDIV2 (0b0000<<1)
#define PEN (1<<0)
#define PDIS (0<<0)

#define IOREG 0xD8

// Serial
const pin_t SCK = {.pin=3, .port=&VPORTA}; //PA3
const pin_t SDI = {.pin=2, .port=&VPORTA}; //PA2
const pin_t SDO = {.pin=1, .port=&VPORTA}; //PA1
const pin_t CS_SCR = {.pin=1, .port=&VPORTC}; //PC1
const pin_t CS_ADC = {.pin=0, .port=&VPORTC}; //PC0

// Gain
const pin_t CS_GAIN = {.pin=4, .port=&VPORTB}; //PB4

// Screen
const pin_t DC = {.pin=3, .port=&VPORTC}; //PC3
const pin_t RST = {.pin=2, .port=&VPORTC}; //PC2
	

void clockSetup()
{
	CCP = IOREG;
	CLKCTRL.MCLKCTRLA = OSC20M;
	
	CCP = IOREG;
	CLKCTRL.MCLKCTRLB = PDIV2 | PDIS;
	
	CCP = IOREG;
	CLKCTRL.MCLKLOCK = 1;
}
 
void pinSetup()
{
#if defined (V1)
	VPORTA.DIR = 0b01111010;
	VPORTB.DIR = 0b00000000;
	VPORTC.DIR = 0b00001111;
#elif defined (V2)
	VPORTA.DIR = 0b01111010;
	VPORTB.DIR = 0b00110000;
	VPORTC.DIR = 0b00001111;
#elif defined (V4)
	VPORTA.DIR = 0b10111100;
	VPORTB.DIR = 0b00100000;
	VPORTC.DIR = 0b00001110;
#elif defined (V5_F)
	VPORTA.DIR = 0b01111010;
	VPORTB.DIR = 0b00010000;
	VPORTC.DIR = 0b00001111;
	PORTA.PIN2CTRL = PULLUPEN;
	VPORTC.OUT = 0x3;
#endif
	
	PORTB.PIN0CTRL = PULLUPEN | INVEN;
	PORTB.PIN1CTRL = PULLUPEN | INVEN;
	PORTB.PIN2CTRL = PULLUPEN | INVEN;
	PORTB.PIN3CTRL = PULLUPEN | INVEN;
}

## Commit log

2018-02-11 V1.0
    This seems ok
2018-02-11 Added components values
2018-02-16 Updated design and curved traces
    Ready to ship !
2018-02-25 spaced a via
2018-03-10 Few changes, added logo
2018-03-11 Added missing dimension
2018-04-21 Code is here !
2018-04-22 Fixed .gitignore
2018-04-22 Something isn't working...
2018-05-07 Small changes in board V2 & more test in programming
    BTW the programm works, the problem came from the not well connected LCD
2018-05-07 Completly separated power lines (analog vs digital)
    And more program tests
2018-05-07 Oops forget to save, see last commit
2018-07-22 V3 will change everything
2018-07-22 Better V3...
2018-08-01 improvement
2020-01-23 Restructured repo
2020-01-23 front and is working
    Common Mode problem, probably due to resistor matching
2020-01-23 LTSpice files
2020-01-23 LTSpice tests
2020-04-17 fix: ugly readme
2020-05-09 Preparing for V5
2020-05-09 Added LTC2315 driver and some PORT/pin black magic
2020-05-09 finishing touches
    ADC is not working, more tests needed
2020-05-10 Trying to match more the spec
2020-05-10 UI base
2020-05-10 why I didn't saw that?
2020-05-10 Schematic for V5
2020-05-11 UI files
